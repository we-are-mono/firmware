# By default, it's set to machine name
hostname = "recovery"